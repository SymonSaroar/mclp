FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://ntpd.cfg"
